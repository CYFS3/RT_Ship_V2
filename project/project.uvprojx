# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, STM32F103xE, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER
  c include: .;rt-thread\libcpu\arm\cortex-m3;rt-thread\include;libraries\HAL_Drivers;packages\cJSON-v1.7.17;packages\gps_rmc-latest;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\include;packages\BA111;rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\HAL_Drivers\drivers\config;board;libraries\HAL_Drivers\drivers;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\smp;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;board\CubeMX_Config\Inc;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\ipc;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;rt-thread\components\drivers\include;applications;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\eventfd;packages\ds18b20-latest\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c control.c data.c lora.c rtk.c 780eg.c
  group ba111
    packages/BA111/: BA111.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON_Utils.c cJSON.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c rt_drv_pwm.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_pwm.c drv_tim.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group ds18b20
    packages/ds18b20-latest/src/: sensor_dallas_ds18b20.c
  group Finsh
    rt-thread/components/finsh/: msh.c shell.c cmd.c msh_parse.c
  group gps_rmc
    packages/gps_rmc-latest/: gps_rmc.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_usart.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cec.c stm32f1xx_hal_uart.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
